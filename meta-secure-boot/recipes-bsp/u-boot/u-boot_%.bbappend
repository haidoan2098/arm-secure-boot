FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://fit-signature.cfg"
